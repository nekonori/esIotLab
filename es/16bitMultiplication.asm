mov r0,#3fh
mov r1,#11h
mov r2,#23h
mov r3,#0f2h
mov a,r1
mov b,r3
mul ab
mov r4,a
mov r5,b
mov a,r0
mov b,r3
mul ab
mov r6,b
add a,r5
mov r5,a
mov a,r1
mov b,r2
mul ab
add a,r5
mov r5,a
mov a,b
add a,r6
mov r6,a
mov a,r0
mov b,r2
mul ab
mov r7,b
add a,r6
mov r6,a
